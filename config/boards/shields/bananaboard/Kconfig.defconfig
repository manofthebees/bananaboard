## config/boards/shields/bananaboard/Kconfig.defconfig
```kconfig
if SHIELD_BANANABOARD

config ZMK_KEYBOARD_NAME
    default "bananaboard"

endif
```
